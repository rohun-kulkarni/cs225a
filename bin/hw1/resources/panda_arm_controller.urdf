Commit message: Hw1 finished.

File: bin/hw1/resources/panda_arm_controller.urdf (robot description, URDF)
Before this commit: robot panda, 8 links, 7 joints
Links:
- link link7: mass 3 -> 0.5
